# IAR project bldc_tester.ewp, settings and files
configuration bldc_tester (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB55RG ST STM32WB55RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WB55xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32WBxx_HAL_Driver/Inc; ../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../Drivers/CMSIS/Include; ..\bldc_driver
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bldc_tester.hex
  ILINK.IlinkOutputFile: bldc_tester.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/bldc_driver
    ../bldc_driver/: bldc_bemf_driver.c bldc_bemf_driver.h bldc_comm_interface.c bldc_comm_interface.h bldc_foc_driver.c bldc_foc_driver.h bldc_hal_sensor_driver.c bldc_hal_sensor_driver.h bldc_master.c bldc_master.h bldc_smooth_transition.c bldc_smooth_transition.h bldc_torque_control.c bldc_torque_control.h bldc_x_definations.h
  group Application/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: bldc_driver_user_interface.c main.c stm32wbxx_hal_msp.c stm32wbxx_it.c
    ../Core/Inc/: bldc_driver_user_interface.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_pcd.c stm32wbxx_hal_pcd_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_ll_usb.c
