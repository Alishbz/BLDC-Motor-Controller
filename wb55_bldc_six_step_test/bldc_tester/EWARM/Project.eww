<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\bldc_tester.ewp</path>
  </project>
  <batchBuild />
</workspace>
